options:
  parameters:
    author: harsha
    generate_options: qt_gui
    id: RX_Combined
    output_language: python
    title: MULTI-RADIO_RECEIVER
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/karthik/Documents/RF_sensing_TEST/850MHz/1m/(2,3)/-15/rep5_rx.dat
    type: float
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1,1,1)
    num_inputs: '4'
    type: float
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"Sync Vector Block\",\n            in_sig=[(np.complex64, 2)],\n            out_sig=[(np.complex64, 2)]\n        )\n\n    def work(self, input_items, output_items):\n        data = input_items[0]\n\n        x1 = data[:, 0]\n        x2 = data[:, 1]\n\n        corr = np.correlate(x1, x2, mode='full')\n        delay = np.argmax(np.abs(corr)) - (len(x1) - 1)\n\n        x2_aligned = np.roll(x2, -delay)\n\n        output_items[0][:, 0] = x1\n        output_items[0][:, 1] = x2_aligned\n\n        return len(output_items[0])\n        \n\n"
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 850e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: 850e6
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 850e6
    dev_addr: serial=32A101F
    gain0: '70'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_1
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 850e6
    dev_addr: serial=3295C76
    gain0: '70'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_stream_mux_0, '0']
- [blocks_complex_to_float_0, '1', blocks_stream_mux_0, '1']
- [blocks_complex_to_float_1, '0', blocks_stream_mux_0, '2']
- [blocks_complex_to_float_1, '1', blocks_stream_mux_0, '3']
- [blocks_stream_mux_0, '0', blocks_file_sink_0, '0']
- [blocks_streams_to_vector_0, '0', epy_block_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_complex_to_float_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_complex_to_float_1, '0']
- [epy_block_0, '0', blocks_vector_to_streams_0, '0']
- [uhd_usrp_source_0, '0', blocks_streams_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_1, '0']
- [uhd_usrp_source_1, '0', blocks_streams_to_vector_0, '1']
- [uhd_usrp_source_1, '0', qtgui_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
